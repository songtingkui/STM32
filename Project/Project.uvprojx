# Keil uVision project Project.uvprojx, settings and files
target HK32F030MF4P6 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HK32F030MF4P6 HK_MicroChip
  pack: HKMicroChip.HK32F030Mxx_DFP.1.0.7
  cpu: IRAM(0x20000000,0x800) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HK32F030M,HK32F030MF4P6
  c include: ..\Source\Libraries\StdPeriph_Driver;..\Source\Libraries\User_Lib;..\Source\Libraries\StdPeriph_Driver\inc;..\Source\Libraries\StdPeriph_Driver\src;..\Source\Libraries\CMSIS\CM0\Core;..\Source\Libraries\CMSIS\CM0;..\Source\Libraries\CMSIS\HK32F030M\Include;..\Source\Libraries\CMSIS\HK32F030M\Source;..\Source\Driver;..\Source\User
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group User
    ../Source/User/: main.c hk32f030m_it.c
  group Driver
    ../Source/Driver/: led.c pwm.c uart.c 03T.c blinker.c eeprom.c ADC.c key.c
  group StdPeriph_Driver
    ../Source/Libraries/StdPeriph_Driver/src/: hk32f030m_rcc.c hk32f030m_gpio.c hk32f030m_tim.c hk32f030m_usart.c hk32f030m_exti.c hk32f030m_misc.c hk32f030m_syscfg.c hk32f030m_flash.c hk32f030m_adc.c
  group Startup
    ../Source/Libraries/CMSIS/HK32F030M/Source/: system_hk32f030m.c KEIL_Startup_hk32f030m.s
  group Doc
    ../Doc/: Readme.txt
  group User_Lib
    ../Source/Libraries/User_Lib/: delay.c softUart.c
